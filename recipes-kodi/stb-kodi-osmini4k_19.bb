require edision-stb-kodi.inc

COMPATIBLE_MACHINE = "^(osmini4k)$"
