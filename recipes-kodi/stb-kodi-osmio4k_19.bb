require edision-stb-kodi.inc

SRC_URI_append = " file://0001-Add-initial-support-for-V4L2-mem2mem-decoder.patch"

COMPATIBLE_MACHINE = "^(osmio4k)$"
