SRCDATE = "20151201"

require edision-v3ddriver.inc

SRC_URI[md5sum] = "01a809640eed5ecd660bd147990a1793"
SRC_URI[sha256sum] = "ba2939f19f5976f5360ff81829cc1407627f6445fb6c115d4d16b9e68b35c008"

COMPATIBLE_MACHINE = "^(osmega)$"
