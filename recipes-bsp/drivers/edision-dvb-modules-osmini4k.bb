KV = "5.5.9"
SRCDATE = "20200313"
MODNAMES = "brcmstb-${MACHINE} ci avl6261 avl6862 si2183"

require os-dvb-modules.inc

COMPATIBLE_MACHINE = "^(osmini4k)$"

SRC_URI[md5sum] = "5dee16030ffb3ea0a556094da26e72c7"
SRC_URI[sha256sum] = "e3f1623c6993f36f64d3dc2228aaf5c04f116901f1d8241986b528768b298962"
SRC_URI[arm64.md5sum] = "5dee16030ffb3ea0a556094da26e72c7"
SRC_URI[arm64.sha256sum] = "e3f1623c6993f36f64d3dc2228aaf5c04f116901f1d8241986b528768b298962"
